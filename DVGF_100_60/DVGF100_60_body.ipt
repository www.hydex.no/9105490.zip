# Autodesk Inventor part: DVGF100_60_body
## iProperties
Created: 2010-04
Part Number: DVGF100_60_body
Document SubType Name: Modeling
Designer: TB
Mass: 2266.53 g
Surface Area: 2607.47 cm^2
Volume: 2266.53 cm^3
Density: 1 g/cm^3
Author: TB
## Feature names
1. Kropp [Revolution]
2. Chamfer
3. Extrusion2
4. Hole1
5. Revolution2
6. Hole2
7. Fillet1
8. Extrusion3
9. Hole3
